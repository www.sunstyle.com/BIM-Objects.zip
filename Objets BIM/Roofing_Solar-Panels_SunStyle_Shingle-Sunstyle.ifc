Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0001
Time: 2020-01-10T13:43:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 10 13:43:18 2020 * Host: Walter-Zerina * Database: C:\Users\user\AppData\Local\Temp\{4A380247-E858-43A9-8668-E69A650635A0}\ifc * Database version: 5507 * Database creation date: Fri Jan 10 13:43:18 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 10 13:43:18 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 10 13:43:18 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Shingle Sunstyle - Black, Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle:Shingle Sunstyle - Black:323568
In: Level 1
Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Rubber - Sunstyle - Black, Glass - Sunstyle - Tainted Black, Steel - Sunstyle - Clear Coated Steel
Pset_BuildingElementProxyCommon - Reference: Shingle Sunstyle - Black
Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1; Default Elevation: 0 mm
Dimensions - Area: 0.778547 m2; Volume: 0.00459704 m3; Length: 870 mm; Width: 870 mm
Other - Category: Generic Models; Schedule Level: Level: Level 1; Family: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle Sunstyle - Black; Family and Type: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle Sunstyle - Black; Type: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle Sunstyle - Black; Type Id: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle Sunstyle - Black; Family Name: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle
Phasing - Phase Created: New Construction
Electrical - Current at Mpp: 8.78 A; Max Fuse Rating: 15 A; Maximum Power: 115 W; Max System Voltage: 1000 V; Open Circuit Voltage: 16.5 V; Short Circuit Current: 9.3 A; Voltage at Mpp: 12.9 V
General - Edition number: 1
Identity Data - Assembly Code: B3010150; Assembly Description: Roofing - Shingle & Tile; Description: Sunstyle International manufactures, sells and distributes the Sunstyle® PV roof which combines clean electricity production, water tightness and aesthetic while generating long term savings for the buildings. The Sunstyle® roofs address the needs of green cities, providing sustainable and autonomous buildings with a perfect integration in the urban landscape.; Keynote: 16050; Manufacturer: SunStyle; Model: Black M115; Product data url: https://bimobject.com/sunstyle/product/115BK-90SV-95TC; Type Comments: Shingle Sunstyle - Black; Type Name: Shingle Sunstyle - Black; URL: www.sunstyle.com
Materials and Finishes - Primary Material: Glass - Sunstyle - Tainted Black

# IfcBuildingElementProxy: Shingle Sunstyle - Silver, Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle:Shingle Sunstyle - Silver:323529
In: Level 1
Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Rubber - Sunstyle - Black, Glass - Sunstyle - Tainted Silver, Steel - Sunstyle - Clear Coated Steel
Pset_BuildingElementProxyCommon - Reference: Shingle Sunstyle - Silver
Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Default Elevation: 0 mm
Dimensions - Area: 0.778547 m2; Volume: 0.00459704 m3; Length: 870 mm; Width: 870 mm
Other - Category: Generic Models; Family: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle Sunstyle - Silver; Family and Type: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle Sunstyle - Silver; Schedule Level: Level: Level 1; Type: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle Sunstyle - Silver; Type Id: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle Sunstyle - Silver; Family Name: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle
Phasing - Phase Created: New Construction
Electrical - Current at Mpp: 6.55 A; Max Fuse Rating: 15 A; Maximum Power: 85 W; Max System Voltage: 1000 V; Open Circuit Voltage: 16.5 V; Short Circuit Current: 6.95 A; Voltage at Mpp: 13.65 V
General - Edition number: 1
Identity Data - Assembly Code: B3010150; Assembly Description: Roofing - Shingle & Tile; Description: Sunstyle International manufactures, sells and distributes the Sunstyle® PV roof which combines clean electricity production, water tightness and aesthetic while generating long term savings for the buildings. The Sunstyle® roofs address the needs of green cities, providing sustainable and autonomous buildings with a perfect integration in the urban landscape.; Keynote: 16050; Manufacturer: SunStyle; Model: Silver M90; Product data url: https://bimobject.com/sunstyle/product/115BK-90SV-95TC; Type Comments: Shingle Sunstyle - Silver; Type Name: Shingle Sunstyle - Silver; URL: www.sunstyle.com
Materials and Finishes - Primary Material: Glass - Sunstyle - Tainted Silver

# IfcBuildingElementProxy: Shingle-Sunstyle - Terracotta, Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle:Shingle-Sunstyle - Terracotta:323582
In: Level 1
Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Rubber - Sunstyle - Black, Glass - Sunstyle - Tainted Terracotta, Steel - Sunstyle - Clear Coated Steel
Pset_BuildingElementProxyCommon - Reference: Shingle-Sunstyle - Terracotta
Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1; Default Elevation: 0 mm
Dimensions - Area: 0.778547 m2; Volume: 0.00459704 m3; Length: 870 mm; Width: 870 mm
Other - Category: Generic Models; Schedule Level: Level: Level 1; Family: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle-Sunstyle - Terracotta; Family and Type: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle-Sunstyle - Terracotta; Type: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle-Sunstyle - Terracotta; Type Id: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle: Shingle-Sunstyle - Terracotta; Family Name: Roofing_Solar-Panels_SunStyle_Shingle-Sunstyle
Phasing - Phase Created: New Construction
Electrical - Current at Mpp: 6.55 A; Max Fuse Rating: 15 A; Maximum Power: 85 W; Max System Voltage: 1000 V; Open Circuit Voltage: 16.5 V; Short Circuit Current: 6.95 A; Voltage at Mpp: 13.65 V
General - Edition number: 1
Identity Data - Assembly Code: B3010150; Assembly Description: Roofing - Shingle & Tile; Description: Sunstyle International manufactures, sells and distributes the Sunstyle® PV roof which combines clean electricity production, water tightness and aesthetic while generating long term savings for the buildings. The Sunstyle® roofs address the needs of green cities, providing sustainable and autonomous buildings with a perfect integration in the urban landscape.; Keynote: 16050; Manufacturer: SunStyle; Model: Terracotta M90; Product data url: https://bimobject.com/sunstyle/product/115BK-90SV-95TC; Type Comments: Shingle-Sunstyle - Terracotta; Type Name: Shingle-Sunstyle - Terracotta; URL: www.sunstyle.com
Materials and Finishes - Primary Material: Glass - Sunstyle - Tainted Terracotta
