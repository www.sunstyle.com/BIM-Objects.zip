Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0001
Time: 2020-01-10T14:01:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 10 14:01:35 2020 * Host: Walter-Zerina * Database: C:\Users\user\AppData\Local\Temp\{134BAD6A-22DC-46A6-BE6D-718CE9D1EFD2}\ifc * Database version: 5507 * Database creation date: Fri Jan 10 14:01:34 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 10 14:01:35 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 10 14:01:35 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Tuile Sunstyle - Noir, Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle:Tuile Sunstyle - Noir:323581
In: Level 1
Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Caoutchouc - Sunstyle - Noir, Acier - Sunstyle - Acier Enduit Clair
Pset_BuildingElementProxyCommon - Reference: Tuile Sunstyle - Noir
Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1; Default Elevation: 0 mm
Dimensions - Area: 0.778547 m2; Volume: 0.00459704 m3; Largeur: 870 mm; Longueur: 870 mm
Other - Category: Generic Models; Schedule Level: Level: Level 1; Family: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Noir; Family and Type: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Noir; Type: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Noir; Type Id: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Noir; Family Name: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle
Phasing - Phase Created: New Construction
Electrical - Courant à Mpp: 8.78 A; Courant Circuit Court: 9.3 A; Fusible Max: 15 A; Puissance Maximale: 115 W; Tension à Circuit Ouvert: 16.5 V; Tension à Mpp: 12.9 V; Tension Maximale Du Système: 1000 V
General - Edition number: 1
Identity Data - Assembly Code: B3010150; Assembly Description: Roofing - Shingle & Tile; Description: Les tuiles photovoltaïques Sunstyle® assurent une intégration optimale de la toiture et de la façade, de manière esthétique, économique et vertueuse. Elles assurent l'étanchéité tout en générant des revenus à long terme pour le bâtiment. Sunstyle® répond aux besoins de la ville verte et autonome en s'intégrant parfaitement dans le paysage urbain. Étanchéité Les tuiles Sunstyle® agissent comme une couverture classique, garantissant l'étanchéité grâce à leur assemblage avec recouvrement similaire à des tuiles classiques. Électricité Les tuiles Sunstyle® sont aussi des modules PV à haute performance, rivalisant avec les centrales solaires au sol, et offrent ainsi production et consommation locales. Esthétique Les tuiles Sunstyle® sont disponibles en couleur, sur mesure, et l'aspect homogène de la couverture permet une intégration visuelle sans égale. Économique Les tuiles Sunstyle® n'offrent pas seulement les avantages d'un produit 2-en-1 mais génèrent aussi de l'électricité propre sur un temps très long (performances garanties 25 ans).; Keynote: 16050; Manufacturer: SunStyle; Model: Noir M115; Product data url: https://bimobject.com/sunstyle/product/115BK-90SV-95TC; Type Comments: Tuile Sunstyle - Noir; Type Name: Tuile Sunstyle - Noir; URL: www.sunstyle.com
Materials and Finishes - Materiau Principal: Caoutchouc - Sunstyle - Noir

# IfcBuildingElementProxy: Tuile Sunstyle - Silver, Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle:Tuile Sunstyle - Silver:323570
In: Level 1
Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Caoutchouc - Sunstyle - Noir, Verre - Sunstyle - Silver Teinté, Acier - Sunstyle - Acier Enduit Clair
Pset_BuildingElementProxyCommon - Reference: Tuile Sunstyle - Silver
Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Default Elevation: 0 mm
Dimensions - Area: 0.778547 m2; Volume: 0.00459704 m3; Largeur: 870 mm; Longueur: 870 mm
Other - Category: Generic Models; Family: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Silver; Family and Type: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Silver; Schedule Level: Level: Level 1; Type: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Silver; Type Id: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Silver; Family Name: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle
Phasing - Phase Created: New Construction
Electrical - Courant à Mpp: 6.55 A; Courant Circuit Court: 6.95 A; Fusible Max: 15 A; Puissance Maximale: 85 W; Tension à Circuit Ouvert: 16.5 V; Tension à Mpp: 13.65 V; Tension Maximale Du Système: 1000 V
General - Edition number: 1
Identity Data - Assembly Code: B3010150; Assembly Description: Roofing - Shingle & Tile; Description: Les tuiles photovoltaïques Sunstyle® assurent une intégration optimale de la toiture et de la façade, de manière esthétique, économique et vertueuse. Elles assurent l'étanchéité tout en générant des revenus à long terme pour le bâtiment. Sunstyle® répond aux besoins de la ville verte et autonome en s'intégrant parfaitement dans le paysage urbain. Étanchéité Les tuiles Sunstyle® agissent comme une couverture classique, garantissant l'étanchéité grâce à leur assemblage avec recouvrement similaire à des tuiles classiques. Électricité Les tuiles Sunstyle® sont aussi des modules PV à haute performance, rivalisant avec les centrales solaires au sol, et offrent ainsi production et consommation locales. Esthétique Les tuiles Sunstyle® sont disponibles en couleur, sur mesure, et l'aspect homogène de la couverture permet une intégration visuelle sans égale. Économique Les tuiles Sunstyle® n'offrent pas seulement les avantages d'un produit 2-en-1 mais génèrent aussi de l'électricité propre sur un temps très long (performances garanties 25 ans).; Keynote: 16050; Manufacturer: SunStyle; Model: Silver M90; Product data url: https://bimobject.com/sunstyle/product/115BK-90SV-95TC; Type Comments: Tuile Sunstyle - Silver; Type Name: Tuile Sunstyle - Silver; URL: www.sunstyle.com
Materials and Finishes - Materiau Principal: Verre - Sunstyle - Silver Teinté

# IfcBuildingElementProxy: Tuile Sunstyle - Terracotta, Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle:Tuile Sunstyle - Terracotta:323592
In: Level 1
Classification: B3010150 Roofing - Shingle & Tile (Uniformat); Material: Caoutchouc - Sunstyle - Noir, Verre - Sunstyle - Terracotta Teinté, Acier - Sunstyle - Acier Enduit Clair
Pset_BuildingElementProxyCommon - Reference: Tuile Sunstyle - Terracotta
Pset_ManufacturerTypeInformation - Manufacturer: SunStyle
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1; Default Elevation: 0 mm
Dimensions - Area: 0.778547 m2; Volume: 0.00459704 m3; Largeur: 870 mm; Longueur: 870 mm
Other - Category: Generic Models; Schedule Level: Level: Level 1; Family: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Terracotta; Family and Type: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Terracotta; Type: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Terracotta; Type Id: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle: Tuile Sunstyle - Terracotta; Family Name: Roofing_Solar-Panels_SunStyle_Tuile-Sunstyle
Phasing - Phase Created: New Construction
Electrical - Courant à Mpp: 6.55 A; Courant Circuit Court: 6.95 A; Fusible Max: 15 A; Puissance Maximale: 85 W; Tension à Circuit Ouvert: 16.5 V; Tension à Mpp: 13.65 V; Tension Maximale Du Système: 1000 V
General - Edition number: 1
Identity Data - Assembly Code: B3010150; Assembly Description: Roofing - Shingle & Tile; Description: Les tuiles photovoltaïques Sunstyle® assurent une intégration optimale de la toiture et de la façade, de manière esthétique, économique et vertueuse. Elles assurent l'étanchéité tout en générant des revenus à long terme pour le bâtiment. Sunstyle® répond aux besoins de la ville verte et autonome en s'intégrant parfaitement dans le paysage urbain. Étanchéité Les tuiles Sunstyle® agissent comme une couverture classique, garantissant l'étanchéité grâce à leur assemblage avec recouvrement similaire à des tuiles classiques. Électricité Les tuiles Sunstyle® sont aussi des modules PV à haute performance, rivalisant avec les centrales solaires au sol, et offrent ainsi production et consommation locales. Esthétique Les tuiles Sunstyle® sont disponibles en couleur, sur mesure, et l'aspect homogène de la couverture permet une intégration visuelle sans égale. Économique Les tuiles Sunstyle® n'offrent pas seulement les avantages d'un produit 2-en-1 mais génèrent aussi de l'électricité propre sur un temps très long (performances garanties 25 ans).; Keynote: 16050; Manufacturer: SunStyle; Model: Terracotta M90; Product data url: https://bimobject.com/sunstyle/product/115BK-90SV-95TC; Type Comments: Tuile Sunstyle - Terracotta; Type Name: Tuile Sunstyle - Terracotta; URL: www.sunstyle.com
Materials and Finishes - Materiau Principal: Verre - Sunstyle - Terracotta Teinté
